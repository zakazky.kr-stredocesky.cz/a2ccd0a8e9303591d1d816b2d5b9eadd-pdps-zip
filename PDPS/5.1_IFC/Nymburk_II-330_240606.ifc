Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [CoordinationView]
File name: Nymburk_II-330_240606.ifc
Time: 2024-06-05T15:31:09
Author: FR
Organization: Exact
Written by: OpenRoadsDesigner 10.10.21.04
Made in: OpenRoadsDesigner 10.10.21.04
Authorization: Administrator

# IfcSite, Nymburk_BIM_ORD_rev3
RefElevation: 0 m

# IfcBuilding, Building
ElevationOfRefHeight: 0 m; ElevationOfTerrain: 0 m

# IfcBuildingStorey, BSMT
In: Building
Description: Basement; Elevation: 185.314 m

# IfcBuildingElementProxy (21)
In: BSMT
Station - Start Station: []; End Station: []
CZ_I1 - ClassificationSystem: CCI 2022-v5.0
CZ_F1 - Status: projekt
Pay Item - General 1 - Description: BITUMINOUS TACK COAT; Item_Number: 40-30010; Unit: SM
Pay Item - Pavement - Density: 2300
Name | Geometry, Volume (m³) (m3) = Civil Quantities, Volume (m³) (m3) | Surface Area (m²) (m2) | Planar Area (m²) (m2) | Top Sloped Area (m²) (m2) = Design_Area (m²) (m2) | Feature Definition | Feature Name | ObjectDesignation | StationingFrom (km) (km) | StationingTo (km) (km) | ConstructionStart | ConstructionEnd = Commissioning | PhaseName | Thickness (m) (m) | Description | Item_Number | Unit | Design_Volume (m³) (m3) | Design_Weight (tn (short)) (tn (short)) | Material | MaterialSpecification | MaterialDetailedSpecification
MeshElement | 120.617 | 4057.42 | 2010.29 | 2010.76 | Mesh\Asphalt\TC_Asph Conc Intermediate Cse | Surface Templates\Asphalt Pavement_lozna_Nymb, TC_lozna_vrstva | SO 101_1 | 0 | 0.29 | 2024-08-01T00:00:00 | 2024-09-01T00:00:00 | etapa 1 | 0.06 | BITUMINOUS PAVEMENT TYPE 2 | 40-10200 | TON | 120.617 | 138.71
MeshElement | 45.5907 | 1531.46 | 759.846 | 760.236 | Mesh\Asphalt\TC_Asph Conc Intermediate Cse | Surface Templates\Asphalt Pavement_lozna_Nymb, TC_lozna_vrstva | SO 101_2 | 0.29 | 0.372842 | 2025-01-01T00:00:00 | 2026-01-01T00:00:00 | etapa 2 | 0.06 | BITUMINOUS PAVEMENT TYPE 2 | 40-10200 | TON | 45.591 | 52.43
MeshElement | 208.626 | 7002.7 | 3477.11 | 3478.68 | Mesh\Asphalt\TC_Asph Conc Intermediate Cse | Surface Templates\Asphalt Pavement_lozna_Nymb, TC_lozna_vrstva | SO 101_3 | 0.372842 | 0.732799 | 2024-08-01T00:00:00 | 2024-09-01T00:00:00 | etapa 3 | 0.06 | BITUMINOUS PAVEMENT TYPE 2 | 40-10200 | TON | 208.626 | 239.92
MeshElement | 109.843 | 3684.09 | 1830.72 | 1831.54 | Mesh\Asphalt\TC_Asph Conc Intermediate Cse | Surface Templates\Asphalt Pavement_lozna_Nymb, TC_lozna_vrstva | SO 101_4a | 0.73 | 0.886 | 2024-08-01T00:00:00 | 2024-09-01T00:00:00 | etapa 4a | 0.06 | BITUMINOUS PAVEMENT TYPE 2 | 40-10200 | TON | 109.843 | 126.319
MeshElement | 165.553 | 5551.67 | 2759.21 | 2759.72 | Mesh\Asphalt\TC_Asph Conc Intermediate Cse | Surface Templates\Asphalt Pavement_lozna_Nymb, TC_lozna_vrstva | SO 101_4b | 0.885 | 1.14 | 2024-08-01T00:00:00 | 2024-09-01T00:00:00 | etapa 4b | 0.06 | BITUMINOUS PAVEMENT TYPE 2 | 40-10200 | TON | 165.553 | 190.386
MeshElement | 113.622 | 3823.79 | 1893.7 | 1894.53 | Mesh\Asphalt\TC_Asph Conc Intermediate Cse | Surface Templates\Asphalt Pavement_lozna_Nymb, TC_lozna_vrstva | SO 101_5 | 1.14 | 1.415 | 2024-08-01T00:00:00 | 2024-09-01T00:00:00 | etapa 5a | 0.06 | BITUMINOUS PAVEMENT TYPE 2 | 40-10200 | TON | 113.622 | 130.665
MeshElement | 41.6066 | 1401.11 | 693.444 | 694.156 | Mesh\Asphalt\TC_Asph Conc Intermediate Cse | Surface Templates\Asphalt Pavement_lozna_Nymb, TC_lozna_vrstva | SO 101_5 | 1.415 | 2.025 | 2024-08-01T00:00:00 | 2024-09-01T00:00:00 | etapa 5b | 0.06 | BITUMINOUS PAVEMENT TYPE 2 | 40-10200 | TON | 41.607 | 47.848
MeshElement | 134.953 | 4542.72 | 2249.21 | 2250.67 | Mesh\Asphalt\TC_Asph Conc Intermediate Cse | Surface Templates\Asphalt Pavement_lozna_Nymb, TC_lozna_vrstva | SO 101_5 | 2.025 | 2.36 | 2024-08-01T00:00:00 | 2024-09-01T00:00:00 | etapa 5c | 0.06 | BITUMINOUS PAVEMENT TYPE 2 | 40-10200 | TON | 134.953 | 155.196
MeshElement | 65.356 | 2199.67 | 1089.27 | 1089.62 | Mesh\Asphalt\TC_Asph Conc Intermediate Cse | Surface Templates\Asphalt Pavement_lozna_Nymb, TC_lozna_vrstva | SO 101_5 | 2.36 | 2.518 | 2024-08-01T00:00:00 | 2024-09-01T00:00:00 | etapa 5d | 0.06 | BITUMINOUS PAVEMENT TYPE 2 | 40-10200 | TON | 65.356 | 75.159
MeshElement | 30.3938 | 1527.79 | 759.846 | 760.236 | Mesh\Asphalt\TC_Asph Conc Wearing Cse | Surface Templates\Asphalt Pavement_obrus_Nymb, TC_obrusna_vrstva | SO 101_2 | 0.29 | 0.372842 | 2025-01-01T00:00:00 | 2026-01-01T00:00:00 | etapa 2 | 0.04 | WEARING COURSE TYPE 1 | 40-30010 | SM | 30.394 | 34.953 | obrusná vrstva | ACO 11+ | ČSN 13108-1
MeshElement | 139.084 | 6987.59 | 3477.11 | 3478.68 | Mesh\Asphalt\TC_Asph Conc Wearing Cse | Surface Templates\Asphalt Pavement_obrus_Nymb, TC_obrusna_vrstva | SO 101_3 | 0.372842 | 0.732799 | 2024-08-01T00:00:00 | 2024-09-01T00:00:00 | etapa 3 | 0.04 | WEARING COURSE TYPE 1 | 40-30010 | SM | 139.084 | 159.947 | obrusná vrstva | ACO 11+ | ČSN 13108-1
MeshElement | 73.2289 | 3677.08 | 1830.72 | 1831.54 | Mesh\Asphalt\TC_Asph Conc Wearing Cse | Surface Templates\Asphalt Pavement_obrus_Nymb, TC_obrusna_vrstva | SO 101_4a | 0.73 | 0.886 | 2024-08-01T00:00:00 | 2024-09-01T00:00:00 | etapa 4a | 0.04 | WEARING COURSE TYPE 1 | 40-30010 | SM | 73.229 | 84.213 | obrusná vrstva | ACO 11+ | ČSN 13108-1
MeshElement | 110.368 | 5540.92 | 2759.21 | 2759.72 | Mesh\Asphalt\TC_Asph Conc Wearing Cse | Surface Templates\Asphalt Pavement_obrus_Nymb, TC_obrusna_vrstva | SO 101_4b | 0.885 | 1.14 | 2024-08-01T00:00:00 | 2024-09-01T00:00:00 | etapa 4b | 0.04 | WEARING COURSE TYPE 1 | 40-30010 | SM | 110.368 | 126.923 | obrusná vrstva | ACO 11+ | ČSN 13108-1
MeshElement | 75.748 | 3812.21 | 1893.7 | 1894.53 | Mesh\Asphalt\TC_Asph Conc Wearing Cse | Surface Templates\Asphalt Pavement_obrus_Nymb, TC_obrusna_vrstva | SO 101_5 | 1.14 | 1.415 | 2024-08-01T00:00:00 | 2024-09-01T00:00:00 | etapa 5a | 0.04 | WEARING COURSE TYPE 1 | 40-30010 | SM | 75.748 | 87.11 | obrusná vrstva | ACO 11+ | ČSN 13108-1
MeshElement | 9.10712 | 367.619 | 182.142 | 182.159 | Mesh\Asphalt\TC_Asph Conc Wearing Cse | Surface Templates\Asphalt Pavement_obrus_Nymb_5, TC_obrusna_vrstva | SO 101_5 | 1.415 | 2.025 | 2024-08-01T00:00:00 | 2024-09-01T00:00:00 | etapa 5b | 0.05 | WEARING COURSE TYPE 1 | 40-30010 | SM | 9.107 | 10.473 | obrusná vrstva | ACO 11+ | ČSN 13108-1
MeshElement | 27.7378 | 1396.85 | 693.444 | 694.156 | Mesh\Asphalt\TC_Asph Conc Wearing Cse | Surface Templates\Asphalt Pavement_obrus_Nymb, TC_obrusna_vrstva | SO 101_5 | 1.415 | 2.025 | 2024-08-01T00:00:00 | 2024-09-01T00:00:00 | etapa 5b | 0.04 | WEARING COURSE TYPE 1 | 40-30010 | SM | 27.738 | 31.899 | obrusná vrstva | ACO 11+ | ČSN 13108-1
MeshElement | 89.9686 | 4528.92 | 2249.21 | 2250.67 | Mesh\Asphalt\TC_Asph Conc Wearing Cse | Surface Templates\Asphalt Pavement_obrus_Nymb, TC_obrusna_vrstva | SO 101_5 | 2.025 | 2.36 | 2024-08-01T00:00:00 | 2024-09-01T00:00:00 | etapa 5c | 0.04 | WEARING COURSE TYPE 1 | 40-30010 | SM | 89.969 | 103.464 | obrusná vrstva | ACO 11+ | ČSN 13108-1
MeshElement | 43.5707 | 2192.86 | 1089.27 | 1089.62 | Mesh\Asphalt\TC_Asph Conc Wearing Cse | Surface Templates\Asphalt Pavement_obrus_Nymb, TC_obrusna_vrstva | SO 101_5 | 2.36 | 2.518 | 2024-08-01T00:00:00 | 2024-09-01T00:00:00 | etapa 5d | 0.04 | WEARING COURSE TYPE 1 | 40-30010 | SM | 43.571 | 50.107 | obrusná vrstva | ACO 11+ | ČSN 13108-1
MeshElement | 80.4115 | 4045.45 | 2010.29 | 2010.76 | Mesh\Asphalt\TC_Asph Conc Wearing Cse | Surface Templates\Asphalt Pavement_obrus_Nymb, TC_obrusna_vrstva | SO 101_1 | 0 | 0.29 | 2024-08-01T00:00:00 | 2024-09-01T00:00:00 | etapa 1 | 0.04 | WEARING COURSE TYPE 1 | 40-30010 | SM | 80.412 | 92.474 | obrusná vrstva | ACO 11+ | ČSN 13108-1
MeshElement | 258.296 | 8679.42 | 4304.93 | 4308.24 | Mesh\Asphalt\TC_Asph Conc Intermediate Cse | Surface Templates\Asphalt Pavement_lozna_Nymb, TC_lozna_vrstva | SO 101_5 | 1.415 | 2.025 | 2024-08-01T00:00:00 | 2024-09-01T00:00:00 | etapa 5b | 0 | BITUMINOUS PAVEMENT TYPE 2 | 40-10200 | TON | 258.296 | 297.04 | ložní vrstva | ACL 16+ | ČSN 13108-1
MeshElement | 172.197 | 8658.44 | 4304.93 | 4308.24 | Mesh\Asphalt\TC_Asph Conc Wearing Cse | Surface Templates\Asphalt Pavement_obrus_Nymb, TC_obrusna_vrstva | SO 101_5 | 1.415 | 2.025 | 2024-08-01T00:00:00 | 2024-09-01T00:00:00 | etapa 5b | 0.04 | WEARING COURSE TYPE 1 | 40-30010 | SM | 172.197 | 198.027 | obrusná vrstva | ACO 11+ | ČSN 13108-1
